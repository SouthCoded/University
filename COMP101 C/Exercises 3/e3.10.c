//Written by Duncan 20/10/17
//Prints numbers in star form 


#include <stdio.h>

char** numberfy(int a){
	
	static char one[5][6] = {
	{' ',' ',' ','*',' ',' '},
	{' ',' ','*','*',' ',' '},
	{' ',' ',' ','*',' ',' '},
	{' ',' ',' ','*',' ',' '},
	{' ',' ','*','*','*',' '},
	};
	static char two[5][6] = {
	{'*','*','*','*','*','*'},
	{' ',' ',' ',' ',' ','*'},
	{'*','*','*','*','*','*'},
	{'*',' ',' ',' ',' ',' '},
	{'*','*','*','*','*','*'},
	};
	static char three[5][6] = {
	{'*','*','*','*','*','*'},
	{' ',' ',' ',' ',' ','*'},
	{'*','*','*','*','*','*'},
	{' ',' ',' ',' ',' ','*'},
	{'*','*','*','*','*','*'},
	};
	static char four[5][6] = {
	{' ',' ','*','*',' ',' '},
	{' ','*',' ','*',' ',' '},
	{'*',' ',' ','*',' ',' '},
	{'*','*','*','*','*','*'},
	{' ',' ',' ','*',' ',' '},
	};
	static char five[5][6] = {
	{'*','*','*','*','*','*'},
	{'*',' ',' ',' ',' ',' '},
	{'*','*','*','*','*','*'},
	{' ',' ',' ',' ',' ','*'},
	{'*','*','*','*','*','*'},
	};
	static char six[5][6] = {
	{'*','*','*','*','*','*'},
	{'*',' ',' ',' ',' ',' '},
	{'*','*','*','*','*','*'},
	{'*',' ',' ',' ',' ','*'},
	{'*','*','*','*','*','*'},
	};
	static char seven[5][6] = {
	{'*','*','*','*','*','*'},
	{' ',' ',' ',' ','*',' '},
	{' ',' ',' ','*',' ',' '},
	{' ',' ','*',' ',' ',' '},
	{' ','*',' ',' ',' ',' '},
	};
	static char eight[5][6] = {
	{'*','*','*','*','*','*'},
	{'*',' ',' ',' ',' ','*'},
	{'*','*','*','*','*','*'},
	{'*',' ',' ',' ',' ','*'},
	{'*','*','*','*','*','*'},
	};
	static char nine[5][6] = {
	{'*','*','*','*','*','*'},
	{'*',' ',' ',' ',' ','*'},
	{'*','*','*','*','*','*'},
	{' ',' ',' ',' ',' ','*'},
	{' ',' ',' ',' ',' ','*'},
	};
	static char zero[5][6] = {
	{'*','*','*','*','*','*'},
	{'*',' ',' ',' ',' ','*'},
	{'*',' ',' ',' ',' ','*'},
	{'*',' ',' ',' ',' ','*'},
	{'*','*','*','*','*','*'},
	};

	switch(a){
		case 0: return **zero;
		case 1: return one;
		case 2: return two;
		case 3: return three;
		case 4: return four;
		case 5: return five;
		case 6: return six;
		case 7: return seven;
		case 8: return eight;
		case 9: return nine;
	}
}


int main(void){

	int first,second,third;
	char grid[5][21] = {
	{' ',' ',' ',' ',' ',' ', ' ',' ',' ',' ',' ',' ',' ', ' ',' ',' ',' ',' ',' ',' ', ' '},
	{' ',' ',' ',' ',' ',' ', ' ',' ',' ',' ',' ',' ',' ', ' ',' ',' ',' ',' ',' ',' ', ' '},
	{' ',' ',' ',' ',' ',' ', ' ',' ',' ',' ',' ',' ',' ', ' ',' ',' ',' ',' ',' ',' ', ' '},
	{' ',' ',' ',' ',' ',' ', ' ',' ',' ',' ',' ',' ',' ', ' ',' ',' ',' ',' ',' ',' ', ' '},
	{' ',' ',' ',' ',' ',' ', ' ',' ',' ',' ',' ',' ',' ', ' ',' ',' ',' ',' ',' ',' ', ' '},
	};
	

	scanf("%i,%i,%i", &first,&second,&third); 

	char** a = numberfy(first);


	//first digit
	for(int d =0 ;d<5;d++){
		for(int e = 0; e<6;e++){
			grid[d][e] = zero[d][e];
		}
	}

	//second digit
	for(int d =0 ;d<5;d++){
		for(int e = 0; e<6;e++){
			grid[d][e+7] = zero[d][e];
		}
	}

	//third digit
	for(int d =0 ;d<5;d++){
		for(int e = 0; e<6;e++){
			grid[d][e+14] = zero[d][e];
		}
	}

	//print all
	for(int d =0 ;d<5;d++){
		for(int e = 0; e<21;e++){
			printf("%c",grid[d][e]);
		}
		printf("\n");
	}



	





}